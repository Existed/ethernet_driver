## Kconfig
```kconfig
config AG71XX 
	tristate "Ethernet Driver for QXA9531"
	depends on ATH79
	select PHYLIB
	help
		Ethernet Driver for QXA9531
```
